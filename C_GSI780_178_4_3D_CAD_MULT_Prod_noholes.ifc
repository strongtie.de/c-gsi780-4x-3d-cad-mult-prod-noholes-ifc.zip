Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-10-02T11:14:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 02 11:14:46 2024 * Host: 105VN589 * Database: C:\Users\truole\AppData\Local\Temp\{E79B359C-4BEF-4290-A719-4C5E85CAED5C}\ifc * Database version: 5507 * Database creation date: Wed Oct 02 11:14:45 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 02 11:14:46 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 02 11:14:46 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-245891 BIMCAD EU_Batch 4.2\Working\3D Contents\Part 5 - 142 models\Remove hole\RFA 3D\GSI780_178_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GSI780_178_4, GSI780_178_4:GSI780_178_4:102155
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: GSI780/178/4
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.000350309 m3
Other - Category: Structural Connections; Family: GSI780_178_4: GSI780_178_4; Family and Type: GSI780_178_4: GSI780_178_4; Schedule Level: Level: Level 1; Type: GSI780_178_4: GSI780_178_4; Type Id: GSI780_178_4: GSI780_178_4; Family Name: GSI780_178_4
Phasing - Phase Created: New Construction
General - Density: 2.52; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSI780/178/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: GSI780/178/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0195429253374650531713348506361334680848; Name: GSI780/178/4; ObjectType: GSI780/178/4; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: GSI780_178_4; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
